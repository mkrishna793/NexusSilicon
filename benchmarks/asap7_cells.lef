VERSION 5.8 ;
NAMESCASESENSITIVE ON ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

MACRO AND2x1
  CLASS CORE ;
  SIZE 0.080 BY 0.240 ;
  SYMMETRY X Y ;
  SITE asap7sc7p5t ;
END AND2x1
